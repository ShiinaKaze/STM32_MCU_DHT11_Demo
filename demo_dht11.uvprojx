# Keil uVision project demo_dht11.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_dht11
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\System;.\Peripheral;.\Module;.\CMSIS\Core;.\CMSIS\Device;.\SPL\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group System
    ./System/: delay.c delay.h
  group Peripheral
    ./Peripheral/: sw_i2c.c sw_i2c.h
  group Module
    ./Module/: dht11.c dht11.h oled.c oled.h oled_font.c oled_font.h
  group CMSIS/Core
    ./CMSIS/Core/: core_cm3.c core_cm3.h
  group CMSIS/Device
    ./CMSIS/Device/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group CMSIS/Device/startup
    ./CMSIS/Device/startup/: startup_stm32f10x_md.s
  group SPL/inc
    ./SPL/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group SPL/src
    ./SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
